# Keil uVision project UT100_Test.uvproj, settings and files
target UT100_Test (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: UT100_Test +hex
  c flags: Optimize=8 SizeSpeed=1
  group UT100
    ./: STARTUP.A51 Uart.c BufferRing.c mian.c DevObj.c Isr.c
